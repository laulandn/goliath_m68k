/*  Metrowerks Standard Library  */

/*  $Date: 2000/07/18 16:59:23 $ 
 *  $Revision: 1.2.10.1.2.1 $ 
 *  $NoKeywords: $ 
 *
 *		Copyright © 1995-2000 Metrowerks, Inc.
 *		All rights reserved.
 */

/*
 *	console_io.mac.c
 *	
 *	Routines
 *	--------
 *		__read_console
 *		__write_console
 *		__close_console
 *
 *
 */

#include "abort_exit.h"
#include "console_io.h"
#include "misc_io.h"
#include "unistd.h"


static int check_console(void)
{
	int	result = 1;
	
	__stdio_atexit();
	
	return(result);
}

int __read_console(__file_handle handle, unsigned char * buffer, size_t * count, __idle_proc idle_proc)
{
#pragma unused(idle_proc)

	if (!check_console())
		return(__io_error);
	
	fflush(stdout);                   /* mm-960717*/
	*count = read(handle, buffer, *count);
	
	if (*count == -1)
		return(__io_error);
	
	return(__no_io_error);
}

int __write_console(__file_handle handle, unsigned char * buffer, size_t * count, __idle_proc idle_proc)
{
#pragma unused(idle_proc)

	if (!check_console())
		return(__io_error);
	
	*count = write(handle, buffer, *count);
	
	if (*count == -1)
		return(__io_error);
	
	return(__no_io_error);
}

int __close_console(__file_handle handle)
{
#pragma unused(handle)

	return(__no_io_error);
}


/*  Change Record
 *	01-Sep-95 JFH  First code release.
 *  15-Dec-95 JFH  Added installation of hook to close console so that RemoveConsole isn't
 *								 called unconditionally at _exit() time.
 *  17-Jul-96 MM   Added flush to make sure that characters awaiting to appear on console
 *                               are output before reading is attemmpted.
 *  18-Jul-00 JWW  #include "unistd.h" to get proper __inline definitions for read/write
 */