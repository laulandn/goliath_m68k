/*
*
*	mpwunix.c
*	Copyright 1995-1997 Metrowerks, Inc. All rights reserved.
*
*	support for calling the CW ANSI libs from CW MPW tools
*
*	The ANSI libs have the following copyright notice.  
*	Copyright (c) 1994 by P.J. Plauger.  ALL RIGHTS RESERVED. 
*	Consult your license regarding permissions and restrictions.
*
*/

#if !defined(Using_StdCLib)

#include <types.h>
#include <string.h>
#include <stdio.h>

#ifndef powerc
#pragma segment Main
#endif

int _Fread(FILE *str, unsigned char *buf, int cnt);
int _Fwrite(FILE *str, const unsigned char *buf, int cnt);

long read(long fd, char *buf, long count);
long write(long fd, const char *buf, long count);

#ifndef __MODENALIB__ 	/*plauger*/
/*
 *	int _Fwrite(FILE *str, const unsigned char *buf, int count)
 *	
 *		Write to a file stream.
 */
int _Fwrite(FILE *str, const unsigned char *buf, int cnt)
{
	return write((str)->_Handle, (const char *)buf, cnt);
}

/*
 *	int _Fread(FILE *str, unsigned char *buf, int count)
 *	
 *		Read from a file stream.
 */
int _Fread(FILE *str, unsigned char *buf, int cnt)
{
	int n = read((str)->_Handle,(char *)buf,cnt);

  	return n;
}
#endif

/*
 *	int isatty(int fileno)
 *
 *		Determines if a filestream is going to the console window.
 */

int isatty(int fildes);
int isatty(int fildes)
{
	if (fildes >=0 && fildes <= 2)
		return 1;
	else
		return 0;
}

/*
 *	int __ctopstring(const char *cstring, Str255 pstring)
 *
 *		Converts a cstring into a pascal string.
 */
int __ctopstring(const char *cstring, Str255 pstring);
int __ctopstring(const char *cstring, Str255 pstring)
{
	int				i;
	unsigned int	len; 

	len = strlen(cstring);
	if (len > 255)
		return (-1);

	pstring[0] = len;
	for (i = 1; *cstring; i++)
		pstring[i] = *cstring++;

	return (0);
}


#if 0
/*
 *	int creat(char *filename, int mode)
 *
 *		Creates and opens a file.
 */

int creat(char *filename, int mode);
int creat(char *filename, int mode)
{
	int omode = O_WRONLY | O_CREAT | O_TRUNC;
	
	if (mode | O_BINARY)
		omode &= O_BINARY;

	return (open(filename, omode));
}
#endif
#endif