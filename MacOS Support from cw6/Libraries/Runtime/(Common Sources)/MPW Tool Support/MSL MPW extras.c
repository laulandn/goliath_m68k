/*961218 bkoz*/

#include <unix.h>
#include <errno.h>
#include <setjmp.h>
#include <signal.h>
#include <stdlib.h>
#include <string.h>
#include "ansi_files.h"
#include "file_io.h"
#include "abort_exit.h"
#include "critical_regions.h"
#include "misc_io.h"

#include <Types.h>
#include <Errors.h>
#include <Files.h>
#include <Gestalt.h>
#include <Traps.h>
#include <OSUtils.h>

/*line 59, 60 of abort_exit.c*/
void (* __stdio_exit)  (void) = 0;
void (* __console_exit)(void) = 0;

/*line 93 of abort_exit.c*/
int	__aborting = 0;

/*line 49 of unix.mac.c*/
/*
 *	long __myraise(long signal);
 *
 *	raise a signal (note that it is not int size dependant)
 */
long __myraise(long signal);

long __myraise(long signal)
{
	return (raise(signal));
}

/*line 59 of unix.mac.c*/
/*
 *	int __system7present(void)
 *	
 *		Determines if System 7 is present.
 */
int __system7present(void);
int __system7present(void)
{
	static int system7present = -1;		/* we only need to check once */
	
	if (system7present < 0) {
		system7present = 0;
		if (GetToolTrapAddress(_Gestalt) != GetToolTrapAddress(_Unimplemented)) {
			long response;
			if (Gestalt(gestaltSystemVersion, &response) == noErr)
				system7present = response >= 0x0700;
		}
	}
	
	return(system7present);
}


/* Creator and Type for files created by the open function */
long    _fcreator = 0L, _ftype = 0L;


long __getcreator(long isbinary);
long __gettype(long isbinary);


/*
 *      long __getcreator(long isbinary)
 *
 *              Returns the creator to use for a file.
 */
long __getcreator(long isbinary)
{
        if (_fcreator)
                return (_fcreator);
        else if (isbinary)
#if __MOTO__
                return ('???\?');
#else
                return ('????');
#endif
        else
                return ('CWIE');
}

/*
 *      long __gettype(long isbinary)
 *
 *              Returns the type to use for a file.
 */
long __gettype(long isbinary)
{
        if (_ftype)
                return (_ftype);
        else if (isbinary)
                return ('BINA');
        else
                return ('TEXT');
}
