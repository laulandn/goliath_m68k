/*  Metrowerks Standard Library  */

/*  $Date: 2000/05/17 17:20:01 $ 
 *  $Revision: 1.2.12.6 $ 
 *  $NoKeywords: $ 
 *
 *		Copyright © 1995-1999 Metrowerks, Inc.
 *		All rights reserved.
 */

/*
 *	File:		unix.win32.c
 *					
 *	Content:	Interface file to standard UNIX-style entry points ...
 *
 *	NB:			This file implements some UNIX low level support.  These functions
 *				are not guaranteed to be 100% conformant.
 *
 */

#include <unix.h>
#include "ansi_files.h"
#include <cerrno>
/*#include <io.h>*/
/*#include <stat.h>*/

/*
 *	FILE *fdopen(int handle, char *mode)
 *
 *		Converts a file handle into an ANSI C file stream.
 */
FILE *_fdopen(int handle, char *mode)
{
	// The Mac version of this routine makes sure that the requested
	// mode can be granted given the permissions of the handle. Currently
	// this routine doesn't do that check.
	
	FILE * theFileP = __find_unopened_file();
	
	if (!theFileP)
		return(0);
	
	return(__handle_reopen(handle, mode, theFileP));
}


/*
 *	int _chmod (const char * __path, mode_t __pmode )
 *
 *		changes file-permissions
 */
 
int _chmod (const char * __path, mode_t __pmode )
{

	WIN32_FIND_DATA FileData;
    HANDLE          hFile;
    DWORD 			error;
    
    if ((hFile = FindFirstFile(__path, &FileData)) == INVALID_HANDLE_VALUE) 
    {
        if ((error=GetLastError()) ==  ERROR_FILE_NOT_FOUND )
        {
                errno = ENOENT;
                return (-1);
         }
               	
    } 
    
    else 
    {
    
    	DWORD __fa;
        __fa = GetFileAttributes(__path);
        
        if ( __pmode & S_IWRITE)
    	{
    	   __fa &= ~FILE_ATTRIBUTE_READONLY;
    	}
    	else
    	{	
    		__fa |= FILE_ATTRIBUTE_READONLY;
    		
    	}
    
 		return 0;
	}
return 0;	
}

/*	Change History
	
961031 KO	Wrote fdopen. Previously it was an empty definition.
980622 mf   got rid of un-needed header files
000210 cc 	moved _tell and __myraise and headers to extras.c  
000215 cc 	added _chmod
000517 cc   cleaned up #includes
*/
